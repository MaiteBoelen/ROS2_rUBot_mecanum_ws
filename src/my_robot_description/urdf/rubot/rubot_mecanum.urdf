Commit message: improvement of urdf file

File: src/my_robot_description/urdf/rubot/rubot_mecanum.urdf (robot description, URDF)
Before this commit: robot rubot, 9 links, 8 joints
Joints:
- joint scan_joint: axis 0 0 1 -> 0 0 3.14; origin xyz=0 0 0.14 rpy=0 0 3.14 -> xyz=0 0 0.14 rpy=0 0 0
